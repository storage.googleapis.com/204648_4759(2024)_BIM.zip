Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 8ded863a-fef2-49e7-b83e-72eb26fb6669, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 4759(2024).ifc
Time: 2025-01-29T22:00:16
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SINK
Name
InPort_374559_1
InPort_374559_3

# IfcFlowController: 4759(2024):4759 Shower faucet with shower set, 160cc, 4759(2024):4759 Shower faucet with shower set, 160cc:374559
In: Level 1
Type - PredefinedType: FAUCET; Material: Chrome
Type - General - Author: BIMStone; BIMObjectName: 4759(2024); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - EN Standard: EN 1111, EN 1112, EN 1113; ETIM Class Number: EC011329 Shower mixing tap; Noise Class: I (ISO 3822); RSK Number: 8283476; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/4759; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/4759
Type - Constraints - Default Elevation: 0 mm
Type - Mechanical - Advanced Features: Inner body made of DZR brass;Flexible length / can be shortened;Anti-twist hose connector; Backflow Prevention EN1717: EB; Connection: Direct connection;Internal thread; Connection Size: M26x1.5; Eco Flow At 300kPa: 0.17 dm3/s; Excluded Items: Without couplings; Flow Rate At 300kPa: 0.18 dm3/s; Hand Shower Size: Ø 110 mm; Installation Type: Wall mounted; Installation Width: 160 mm; Lever Handle: Temperature control handle;Flow control handle;Hot/Cold symbols;Eco feature for water flow; Max. Hot Water Supply: 65 C; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Pressure Loss With Flow 02ls: 185000 Pa; Shower Parts: Hand shower;Shower rail;Adjustable shower rail bracket;Soap dish;Shower hose (1750 mm);Variable fixing points;Anti limescale technology (easy to clean);Twist guard for shower hose; Shower Spray: Pulsating - Strong water stream for massage or body treatment;Intense - invigorating water stream;Relaxing - Soft water stream, pleasant for entire body; Shower Spray Number: 3 spray functions; Surface treatment: Chrome; Temperature Adjustments: Safety stop against scalding at 38°C;The housing of the fittings conducts minimal heat; Working Pressure: 100 - 1000 kPa
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Construction - Type: 0 mm
Type - Dimensions - NominalDepth: 172.1 mm; NominalHeight: 100.184 mm; NominalWidth: 300.3 mm
Type - Identity Data - 3D View: https://static.oras.com/3D/4759; Ambience photo: http://static.oras.com/ambience/4759; Catalog Drawing URL: http://static.oras.com/catdrw/4759; Category B2C: Shower solutions; Color variants: 4759-33; Dimension Drawing URL: http://static.oras.com/dimdrw/4759; FDV Document URL: http://www.oras.com/datasheet/4759/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/4759; Group: ShowerFaucetsWithShowerSet; Installation and Maintenance Guide URL: http://static.oras.com/manual/4759; Interactive AR View URL: https://static.oras.com/AR/4759; Lifestyle photo: http://static.oras.com/lifestyle/4759; Long Marketing: Oras Aurelia. A Harmony of Simplicity and Elegance. The timeless silhouette of an ancient, handcrafted bridge, perfectly mirrored in tranquil waters, evolves into a slender and elegant cylindric thermostat. Meticulously designed handles seamlessly complete the form without compromising functionality, exuding elegance from every angle. The perfect designed handles completing the design with out losing its functionality. It becomes easy with simple, in few movement to adjust flow and temperature for your decried settings for the perfect shower experience. AURELIA draws design inspiration from the exquisite elements of wild nature. From the graceful Lotus flower transformed into a spray face, designed for pure enjoyment, to the simplest curve of a tiny waterdrop. . 110mm – 3 spray face Handshower Easy push diverter for simple selection of spray face Easy to adjust shower holder 160cc ELEVATING YOUR MOMENTS; Manufacturer: Oras; Market: International;Sweden; Mobile Product Information URL: http://mpi.oras.com/4759; Model: 4759 Shower faucet with shower set, 160cc; Name_en: 4759 Shower faucet with shower set, 160cc; OmniClass Number: 23.45.55.00; Product Code: 4759; Product Family: Oras Aurelia; Product Image URL: http://static.oras.com/image/4759; Product URL: http://static.oras.com/4759; Technical DataSheet URL: http://www.oras.com/datasheet/4759/en; Type Name: 4759 Shower faucet with shower set, 160cc; Warranty Information URL: http://warranty.oras.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 4759(2024); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 4759; Name: 4759 Shower faucet with shower set, 160cc; ReplacementCost: n/a; Shape: Sculptured; Size: 220 x 240 x 180 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 4759; Manufacturer: Oras
Type - Pset_ProductRequirements - Name: 4759 Shower faucet with shower set, 160cc
Type - Pset_ValveTypeCommon - ValvePattern: OTHER; ValveOperation: OTHER; ValveMechanism: OTHER; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Material: <Unnamed>, Chrome
Pset_DistributionFlowElementCommon - Reference: 4759 Shower faucet with shower set, 160cc; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Offset from Host: 0 mm
Phasing - Phase Created: New Construction
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Dimensions - Area: 0.536394 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.0527917 m3
Identity Data - Mark: 9
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 4759(2024); Family and Type: 4759(2024): 4759 Shower faucet with shower set, 160cc; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 4759 Shower faucet with shower set, 160cc; Type Id: 374541; WarrantyStartDate: n/a
